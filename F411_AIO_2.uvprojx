# Keil uVision project F411_AIO_2.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F411_AIO_2 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: ibus.c ibus.h main.c RCC_Config.c RCC_Config.h timer.c timer.h usart.c usart.h SPI.c SPI.h mpu6000.h mpu6000.c complementary_filter.c complementary_filter.h global.h LED_Config.h LED_Config.c task.h task.c pid.c pid.h mixer.c mixer.h MahonyAHRS.c MahonyAHRS.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
